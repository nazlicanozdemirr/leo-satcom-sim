options:
  parameters:
    author: LEO Satcom Sim
    comment: Ideal Phase 2 transmitter; no channel block is present.
    description: LDPC coded, PN63 framed, differential Gray-QPSK transmitter
    generate_options: no_gui
    id: tx_chain
    output_language: python
    title: LEO TX Chain
  states: {}

blocks:
- name: import_project
  id: import
  parameters:
    comment: Load all transmitter constants from the Phase 0 configuration.
    imports: |-
      from pathlib import Path
      import random
      from config import params
      from gnuradio.filter import firdes
      from tx.tx_chain import unit_energy_qpsk_points
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: params.samp_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: params.sym_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: params.sps
  states: {}
- name: qpsk_constellation
  id: variable
  parameters:
    comment: GNU Radio Gray-labelled QPSK object
    value: digital.constellation_qpsk().base()
  states: {}
- name: alist_path
  id: variable
  parameters:
    comment: Launch GRC from the project root.
    value: str((Path.cwd() / 'data' / 'ldpc_128_64_regular.alist').resolve())
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: Interpolating RRC taps; gain=sps keeps symbol amplitude normalized.
    value: firdes.root_raised_cosine(sps, samp_rate, sym_rate, params.rrc_rolloff, params.rrc_ntaps)
  states: {}
- name: payload_bits
  id: variable
  parameters:
    comment: Deterministic random 64-bit payload blocks for standalone execution.
    value: tuple(random.Random(params.tx_random_seed).choices((0, 1), k=params.ldpc_k_short * 100))
  states: {}
- name: ldpc_encoder_object
  id: variable_ldpc_encoder_def
  parameters:
    comment: Deterministic full-rank (3,6)-regular rate-1/2 LDPC encoder object.
    file: alist_path
    ndim: '0'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Repeating random message source; every 64 bytes form one payload block.
    data: payload_bits
    repeat: 'True'
    type: byte
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    comment: Encode each k=64 message block into one n=128 LDPC codeword.
    encoder_list: ldpc_encoder_object
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: epy_frame_builder
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the reusable PN63 frame builder."""

      from tx.tx_chain import _FramePreambleInserter


      class blk(_FramePreambleInserter):
          """Insert PN63 before each encoded payload and append one pad bit."""

          def __init__(self):
              """Create the project frame builder with config defaults."""
              super().__init__()
    comment: Preamble is outside LDPC so the encoder still receives exactly 64 payload bits.
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Pack the 192-bit frame into 96 QPSK dibit indices.
    k: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Apply constellation pre-differential map so Gray labels become phase increments.
    map: qpsk_constellation.pre_diff_code()
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Mod-4 differential coding resolves the QPSK Costas loop's fourfold phase ambiguity.
    modulus: '4'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map the differential indices to unit-power Gray-labelled QPSK points.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: unit_energy_qpsk_points(qpsk_constellation)
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: RRC pulse shaping and x4 interpolation using Phase 0 parameters.
    interp: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Standalone flowgraph rate limiter; remove when connected to hardware.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    bus_structure: '[[0,],]'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', fec_extended_encoder_0, '0']
- [fec_extended_encoder_0, '0', epy_frame_builder, '0']
- [epy_frame_builder, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
