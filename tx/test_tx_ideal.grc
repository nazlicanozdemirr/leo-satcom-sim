options:
  parameters:
    author: LEO Satcom Sim
    comment: No channel, noise, Doppler, timing error, or carrier error.
    description: Ideal matched-filter constellation check for the Phase 2 transmitter
    generate_options: qt_gui
    id: test_tx_ideal
    output_language: python
    title: Ideal TX QPSK Constellation
  states: {}

blocks:
- name: import_project
  id: import
  parameters:
    imports: |-
      import random
      from config import params
      from gnuradio.filter import firdes
      from rx.rx_sync_chain import make_rx_rrc_taps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: params.samp_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: params.sym_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: params.sps
  states: {}
- name: qpsk_constellation
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: rx_rrc_taps
  id: variable
  parameters:
    comment: Unit-gain ideal matched RRC used only to observe symbol instants.
    value: make_rx_rrc_taps(samp_rate, sym_rate, params.rrc_rolloff, params.rrc_ntaps)
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: tuple(random.Random(params.tx_random_seed).choices((0, 1), k=params.ldpc_k_short * 100))
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Repeat complete 64-bit LDPC payload blocks.
    data: payload_bits
    repeat: 'True'
    type: byte
  states: {}
- name: epy_tx_chain
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the reusable Phase 2 transmitter."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from tx.tx_chain import tx_chain


      class blk(gr.basic_block):
          """Expose the config-driven TX hierarchy in the ideal GUI test."""

          def __new__(cls):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return tx_chain()

          def __init__(self):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "LEO TX Chain",
                  in_sig=[np.uint8],
                  out_sig=[np.complex64],
              )
    comment: Full LDPC + PN63 + differential Gray-QPSK + TX RRC hierarchy.
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: GUI-only rate limiter.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Ideal matched RRC and exact x4 decimation; not a channel or synchronizer.
    decim: sps
    taps: rx_rrc_taps
    type: ccf
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Hard symbol decisions at ideal symbol instants.
    constellation: qpsk_constellation
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    bus_structure: '[[0,],]'
    comment: Consume ideal hard decisions; RX decoding is a later phase.
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Four compact points are expected because no channel impairment is present.
    grid: 'True'
    label1: Ideal matched-filter QPSK
    name: '"Ideal TX QPSK"'
    size: '4096'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_tx_chain, '0']
- [epy_tx_chain, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
