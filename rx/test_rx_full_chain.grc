options:
  parameters:
    author: LEO Satcom Sim
    comment: Selectable FEC full receiver with live constellation and rolling EVM.
    description: Phase 4 TX to channel to synchronization to FEC decode visualization
    generate_options: qt_gui
    id: test_rx_full_chain
    output_language: python
    title: LEO Full RX FEC and EVM
  states: {}

blocks:
- name: decoder_type
  id: variable
  parameters:
    comment: Use "uncoded", "ldpc" or "viterbi"; TX and RX must match.
    value: '"ldpc"'
  states: {}
- name: ebno_db
  id: variable
  parameters:
    comment: Live channel Eb/No
    value: '8.0'
  states: {}
- name: effective_t_sys
  id: variable
  parameters:
    comment: Normalized Eb/No converted to the Phase 1 kTB interface.
    value: (params.sps / (2.0 * code_rate_for(decoder_type) * 10.0**(ebno_db / 10.0))) / (BOLTZMANN_J_PER_K * params.signal_bandwidth_hz)
  states: {}
- name: payload_bits
  id: variable
  parameters:
    comment: Complete 64-bit payload blocks.
    value: tuple(random.Random(params.tx_random_seed).choices((0, 1), k=params.ldpc_k_short * 1000))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: params.samp_rate
  states: {}
- name: blocks_null_sink_codeword
  id: blocks_null_sink
  parameters:
    comment: Pre-FEC hard codeword output.
    type: byte
  states: {}
- name: blocks_null_sink_payload
  id: blocks_null_sink
  parameters:
    comment: Decoded payload output.
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: GUI-only rate limiter.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0)
  states: {}
- name: epy_channel
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the Phase 1 LEO channel."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from channel.leo_channel_model import leo_channel_model


      class blk(gr.basic_block):
          """Expose AWGN-only defaults for the FEC/EVM view."""

          def __new__(cls, t_sys_kelvin=1.0):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return leo_channel_model(
                  t_sys_kelvin=t_sys_kelvin,
                  doppler_max_hz=0.0,
                  phase_noise_std=0.0,
                  scintillation_std_db=0.0,
                  path_loss_db=0.0,
              )

          def __init__(self, t_sys_kelvin=1.0):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "LEO Channel Model",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
    comment: AWGN-only view keeps FEC comparison deterministic.
    t_sys_kelvin: effective_t_sys
  states: {}
- name: epy_evm
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for analysis.evm_calc.EVMStreamBlock."""

      from analysis.evm_calc import EVMStreamBlock


      class blk(EVMStreamBlock):
          """Expose rolling QPSK EVM percentage."""

          def __init__(self, window_size=1000):
              """Construct the shared EVM measurement block."""
              super().__init__(window_size=window_size)
    comment: Same nearest-QPSK formula as the offline EVM report.
    window_size: params.evm_window_symbols
  states: {}
- name: epy_fec_tx
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the selectable Phase 4 FEC transmitter."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from rx.rx_full_chain import fec_tx_chain


      class blk(gr.basic_block):
          """Expose matching LDPC or convolutional coding."""

          def __new__(cls, decoder_type="ldpc"):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return fec_tx_chain(decoder_type=decoder_type)

          def __init__(self, decoder_type="ldpc"):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "Selectable FEC TX Chain",
                  in_sig=[np.uint8],
                  out_sig=[np.complex64],
              )
    decoder_type: decoder_type
  states: {}
- name: epy_full_rx
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the complete Phase 4 receiver."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from rx.rx_full_chain import rx_full_chain


      class blk(gr.basic_block):
          """Expose synchronized symbols and selected FEC output."""

          def __new__(cls, decoder_type="ldpc"):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return rx_full_chain(decoder_type=decoder_type)

          def __init__(self, decoder_type="ldpc"):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "LEO Full RX Chain",
                  in_sig=[np.complex64],
                  out_sig=[np.uint8, np.complex64, np.uint8],
              )
    comment: Output 0 payload, output 1 synchronized symbols, output 2 hard codeword bits.
    decoder_type: decoder_type
  states: {}
- name: import_project
  id: import
  parameters:
    imports: |-
      import random
      from config import params
      from channel.leo_channel_model import BOLTZMANN_J_PER_K
      from rx.rx_full_chain import code_rate_for
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: Costas and Gardner synchronized QPSK symbols.
    grid: 'True'
    label1: Synchronized QPSK
    name: '"Synchronized QPSK"'
    size: '4096'
    type: complex
  states: {}
- name: qtgui_number_sink_evm
  id: qtgui_number_sink
  parameters:
    avg: '0.05'
    color1: ("blue", "red")
    comment: Rolling 1000-symbol RMS EVM from analysis/evm_calc.py.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: RMS EVM
    max: '100'
    min: '0'
    name: '"QPSK EVM"'
    type: float
    unit1: '%'
  states: {}

connections:
- [blocks_throttle2_0, '0', epy_channel, '0']
- [blocks_vector_source_x_0, '0', epy_fec_tx, '0']
- [epy_channel, '0', epy_full_rx, '0']
- [epy_evm, '0', qtgui_number_sink_evm, '0']
- [epy_fec_tx, '0', blocks_throttle2_0, '0']
- [epy_full_rx, '0', blocks_null_sink_payload, '0']
- [epy_full_rx, '1', epy_evm, '0']
- [epy_full_rx, '1', qtgui_const_sink_x_0, '0']
- [epy_full_rx, '2', blocks_null_sink_codeword, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
