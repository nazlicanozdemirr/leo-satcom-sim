options:
  parameters:
    author: LEO Satcom Sim
    comment: TX -> LEO channel -> matched RRC -> Costas -> Gardner timing recovery
    description: Phase 3 QPSK synchronization and lock-metric visualization
    generate_options: qt_gui
    id: rx_sync_chain
    output_language: python
    title: LEO RX Synchronization Chain
  states: {}

blocks:
- name: import_project
  id: import
  parameters:
    imports: |-
      import random
      from config import params
      from gnuradio.filter import firdes
      from channel.leo_channel_model import BOLTZMANN_J_PER_K
      from rx.rx_sync_chain import make_rx_rrc_taps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: params.samp_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: params.sym_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: params.sps
  states: {}
- name: ebno_db
  id: variable
  parameters:
    comment: Test Eb/No in dB
    value: '6.0'
  states: {}
- name: effective_t_sys
  id: variable
  parameters:
    comment: Convert normalized QPSK Eb/No noise power into the channel kTB interface.
    value: (sps / (2.0 * params.ldpc_code_rate * 10.0**(ebno_db / 10.0))) / (BOLTZMANN_J_PER_K * params.signal_bandwidth_hz)
  states: {}
- name: qpsk_constellation
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: inverse_pre_diff
  id: variable
  parameters:
    comment: Undo the Phase 2 QPSK pre-differential label mapping.
    value: '[list(qpsk_constellation.pre_diff_code()).index(i) for i in range(4)]'
  states: {}
- name: rx_rrc_taps
  id: variable
  parameters:
    comment: Same roll-off and tap count as TX, with unit receiver gain.
    value: make_rx_rrc_taps(samp_rate, sym_rate, params.rrc_rolloff, params.rrc_ntaps)
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: tuple(random.Random(params.tx_random_seed).choices((0, 1), k=params.ldpc_k_short * 1000))
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Complete 64-bit payload blocks for the TX hierarchy.
    data: payload_bits
    repeat: 'True'
    type: byte
  states: {}
- name: epy_tx_chain
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the reusable Phase 2 transmitter."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from tx.tx_chain import tx_chain


      class blk(gr.basic_block):
          """Expose the config-driven TX hierarchy."""

          def __new__(cls):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return tx_chain()

          def __init__(self):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "LEO TX Chain",
                  in_sig=[np.uint8],
                  out_sig=[np.complex64],
              )
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: GUI-only rate limiter.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_leo_channel
  id: epy_block
  parameters:
    _source_code: |-
      """GRC adapter for the reusable Phase 1 LEO channel."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from channel.leo_channel_model import leo_channel_model


      class blk(gr.basic_block):
          """Expose the LEO channel with synchronization-test defaults."""

          def __new__(cls, t_sys_kelvin=1.0, doppler_max_hz=8000.0):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return leo_channel_model(
                  t_sys_kelvin=t_sys_kelvin,
                  doppler_max_hz=doppler_max_hz,
                  phase_noise_std=0.0,
                  scintillation_std_db=0.0,
                  path_loss_db=0.0,
              )

          def __init__(self, t_sys_kelvin=1.0, doppler_max_hz=8000.0):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "LEO Channel Model",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
    comment: Eb/No=6 dB AWGN plus slowly varying 8 kHz Doppler; no path loss scaling.
    doppler_max_hz: '8000.0'
    t_sys_kelvin: effective_t_sys
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Matched RRC; retains 4 samples/symbol for Gardner.
    decim: '1'
    taps: rx_rrc_taps
    type: ccf
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Fourth-order QPSK carrier/phase tracking loop.
    order: '4'
    w: params.costas_loop_bw
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Non-data-aided Gardner timing recovery, one output sample/symbol.
    constellation: qpsk_constellation
    damping: '1.0'
    loop_bw: params.timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Hard QPSK symbol decisions after carrier and timing lock.
    constellation: qpsk_constellation
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Undo Phase 2 mod-4 coding and remove Costas fourfold absolute-phase ambiguity.
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Restore original Gray-labelled dibit indices.
    map: inverse_pre_diff
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Convert QPSK dibits back to one bit per byte.
    k: '2'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    bus_structure: '[[0,],]'
    comment: LDPC/frame decoding follows in a later phase.
    type: byte
  states: {}
- name: qtgui_time_sink_costas
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Frequency, phase and detector error settle when the Costas loop locks.
    grid: 'True'
    label1: Frequency estimate
    label2: Phase estimate
    label3: Phase detector error
    name: '"Costas Lock Metrics"'
    nconnections: '3'
    size: '4096'
    srate: samp_rate
    type: float
    ylabel: Loop metric
  states: {}
- name: qtgui_time_sink_timing
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Gardner timing detector error settles around zero at lock.
    grid: 'True'
    label1: Gardner timing error
    name: '"Gardner Timing Error"'
    size: '4096'
    srate: sym_rate
    type: float
    ylabel: Timing error
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_tx_chain, '0']
- [epy_tx_chain, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_leo_channel, '0']
- [epy_leo_channel, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '1', qtgui_time_sink_costas, '0']
- [digital_costas_loop_cc_0, '2', qtgui_time_sink_costas, '1']
- [digital_costas_loop_cc_0, '3', qtgui_time_sink_costas, '2']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_timing, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
