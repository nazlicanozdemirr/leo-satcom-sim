options:
  parameters:
    author: LEO Satcom Sim
    comment: Doppler spectrum track and phase-noise time-domain inspection
    description: Standalone visual test for the LEO channel model
    generate_options: qt_gui
    id: test_channel_standalone
    output_language: python
    title: LEO Channel Standalone Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Complex baseband sample rate
    value: '2000000'
  states: {}
- name: doppler_max_hz
  id: variable
  parameters:
    comment: S-band example Doppler limit
    value: '40000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: Constant complex CW at baseband DC
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Keep the GUI flowgraph at real-time sample rate
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """Thin GRC adapter for the project LEO channel hier block."""

      import inspect
      import numpy as np
      from gnuradio import gr
      from channel.leo_channel_model import leo_channel_model


      class blk(gr.basic_block):
          """Expose leo_channel_model parameters inside GNU Radio Companion."""

          def __new__(
              cls,
              samp_rate=2000000,
              t_sys_kelvin=290.0,
              signal_bandwidth_hz=500000.0,
              phase_noise_std=0.002,
              doppler_max_hz=40000.0,
              doppler_profile="linear",
              scintillation_std_db=0.5,
              path_loss_db=0.0,
              doppler_pass_duration_s=10.0,
              scintillation_cutoff_hz=2.0,
              random_seed=24301,
          ):
              """Return the tested reusable GNU Radio hierarchy."""
              if any(frame.function == "extract" for frame in inspect.stack()):
                  return super().__new__(cls)
              return leo_channel_model(
                  samp_rate=samp_rate,
                  t_sys_kelvin=t_sys_kelvin,
                  signal_bandwidth_hz=signal_bandwidth_hz,
                  phase_noise_std=phase_noise_std,
                  doppler_max_hz=doppler_max_hz,
                  doppler_profile=doppler_profile,
                  scintillation_std_db=scintillation_std_db,
                  path_loss_db=path_loss_db,
                  doppler_pass_duration_s=doppler_pass_duration_s,
                  scintillation_cutoff_hz=scintillation_cutoff_hz,
                  random_seed=random_seed,
              )

          def __init__(
              self,
              samp_rate=2000000,
              t_sys_kelvin=290.0,
              signal_bandwidth_hz=500000.0,
              phase_noise_std=0.002,
              doppler_max_hz=40000.0,
              doppler_profile="linear",
              scintillation_std_db=0.5,
              path_loss_db=0.0,
              doppler_pass_duration_s=10.0,
              scintillation_cutoff_hz=2.0,
              random_seed=24301,
          ):
              """Expose the factory signature to GRC."""
              gr.basic_block.__init__(
                  self,
                  "LEO Channel Model",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
    comment: Reusable LEO space-channel hier_block2
    doppler_max_hz: doppler_max_hz
    doppler_pass_duration_s: '10.0'
    doppler_profile: '"linear"'
    path_loss_db: '0.0'
    phase_noise_std: '0.002'
    random_seed: '24301'
    samp_rate: samp_rate
    scintillation_cutoff_hz: '2.0'
    scintillation_std_db: '0.5'
    signal_bandwidth_hz: '500000.0'
    t_sys_kelvin: '290.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    comment: Observe the Doppler-shifted CW moving across frequency
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    label1: Channel output
    name: '"LEO Doppler Spectrum"'
    type: complex
    width1: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Observe phase rotation and random-walk jitter in I/Q
    grid: 'True'
    label1: Channel output
    name: '"LEO Phase Noise"'
    size: '4096'
    srate: samp_rate
    type: complex
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
